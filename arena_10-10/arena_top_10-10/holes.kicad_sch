File: arena_10-10/arena_top_10-10/holes.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: produced v1.1.7
Other:
- title: G6 Teensy 10-10 Arena -> G6 10-10 Arena Top
